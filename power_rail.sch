File: power_rail.sch (KiCad schematic (older format))
At the start: 0 parts

Commit message: update power rail,
Connections:
- net labels added: VCC3V3-SDC
